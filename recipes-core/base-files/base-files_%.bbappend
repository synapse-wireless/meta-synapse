# Set our default hostname to 'e10' to match the 1.0 and 1.1 image
hostname = 'e10'

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
